# Repository A3zuta/RobotGrandPrix_PCBs

File README.md:

# Robot_Lancer(KiCAD_Project)

*2020 year* <br>
Aqualius Sadalmeric...Power+MD(x6)+Main isolation<br>
AloeSetMeal...Power+MD(x6)+ServoMotor(x1)+Main non-isolation<br>
LineSensor...LineTraceSensor Circuit <br>

## KiCad design Aqualius_Sadalsuud_for_KITRP/Main.kicad_pcb

Parts:
C1, C3: 22p; C_0603_1608Metric
C2, C4, C5, C6, C8, C9, C10, C11, C13, C16, C17, C18, C19, C21, C22, C23, C24, C25, C29, C33, C34, C36, C37, C38, C39, C40, C41, C44, C45, C46, C47, C48, C49, C62, C63, C64, C65, C66, C67, C79, C80, C81, C82, C83, C84, C85: 0.1u; C_0603_1608Metric
C7, C12, C14, C26, C27, C78: 1u; C_0603_1608Metric
C15: 4.7u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C20: 10u; C_0805_2012Metric
C28, C59: 10u; C_0603_1608Metric
C30, C50, C74, C75, C86, C87: 4.7u; C_0603_1608Metric
C31: 22u; C_0603_1608Metric
C32, C35: 2.2u; C_0603_1608Metric
C42: 470u; CP_Radial_D6.3mm_P2.50mm
C43: 15000p; C_0603_1608Metric
C51: 100u; CP_Radial_D6.3mm_P2.50mm
C52: 220u; CP_Radial_D8.0mm_P3.50mm
C53, C54, C55, C56, C57, C58, C68, C69, C70, C71, C72, C73, C76, C77: 4.7u; C_0805_2012Metric
C60, C61: 470u; CAPAE1300X1400N
D1, D28: LED0; LED_0603_1608Metric
D2, D29: LED1; LED_0603_1608Metric
D3: XA_5V; LED_0603_1608Metric
D4: 12V-5V; LED_0603_1608Metric
D5: 5Vc; LED_0603_1608Metric
D6: 12V; LED_0603_1608Metric
D7, D30: LED2; LED_0603_1608Metric
D8: 5V; LED_0603_1608Metric
D9: 3V3; LED_0603_1608Metric
D10, D31: LED3; LED_0603_1608Metric
D11: LED4; LED_0603_1608Metric
D12, D14, D16, D20, D23, D24, D25, D33, D34, D35, D39, D47, D56, D58: DIODE; D_SOD-123
D13: LED5; LED_0603_1608Metric
D21: LED6; LED_0603_1608Metric
D22: LED7; LED_0603_1608Metric
D26: DIODE; D_SMA
D36: BATT; LED_0603_1608Metric
D37: DATA; LED_0603_1608Metric
D38: MAIN; LED_0603_1608Metric
D40, D41, D42, D43, D44, D45, D50, D51, D52, D53, D54, D55: DIODE; D_0603_1608Metric
D46: 5Vp; LED_0603_1608Metric
D48: MOTOR_BATT; LED_0603_1608Metric
D49: COMM; LED_0603_1608Metric
D57: 12Vp; LED_0603_1608Metric
ISO1, ISO2: Si8660; SOIC-16_3.9x9.9mm_P1.27mm
J1: microSD; microSD_HC_Hirose_DM3AT-SF-PEJM5
J2: ADC; PinHeader_1x10_P2.54mm_Vertical
J3: SWD; PinHeader_1x05_P2.54mm_Vertical
J4, J7: CAN; XA_4P
J5: ADC_Vdd; PinHeader_2x10_P2.54mm_Vertical
J6: SERIAL0; XA_4P
J8: VALVE; PinHeader_1x08_P2.54mm_Vertical
J9: SERIAL2; XA_4P
J10: I/O_Vdd; PinHeader_2x08_P2.54mm_Vertical
J11: ENC1; XA_4P
J12: ENC0; XA_4P
J13: ENC3; XA_4P
J14: ENC2; XA_4P
J15: 5Vin; XA_2P
J16: EMG; XA_2P
J17: MOTOR0; XT30_F
J18: MOTOR1; XT30_F
J19: MOTOR2; XT30_F
J20: MOTOR3; XT30_F
J21: MOTOR4; XT30_F
J22: MOTOR5; XT30_F
J23: BATT_IN; XT60_F
J24: BATT_IN; XT60_M
J25: FUSE; 3522-2; Manufacturer_Part_Number 3522-2
J27: Advanced_SBDBT; USB_A_Vertical
J28: PICkit3; ZH_6P
JP1: SWD_Vdd; GS2
JP3: CAN_JP; PinHeader_1x02_P2.54mm_Vertical
JP4: VALVE_JP; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm
JP5: PIKkit_Vdd; GS2
L1, L2: 22uH; Inductor_Taiyo-Yuden_NR-50xx_HandSoldering
LS1: Speaker; UGCT7525AN4
Q1: NPN; SOT-23W
Q2, Q3, Q4: FET_P; SOT-23W
Q5, Q6, Q7, Q8, Q9, Q10, Q12, Q13, Q14, Q15, Q16, Q17: NVMFD5C446NLT1G; NVMFD5C446NLWFT1G; Mouser Part Number 863-NVMFD5C446NLT1G
Q11: FET_N; SOT-23W
Q18: FET_P; SOT-23
R1, R2, R3, R6, R57, R68: 510; R_0603_1608Metric
R4, R83: 1.2k; R_0603_1608Metric
R5, R24, R25, R27, R40, R41, R45, R53, R54, R55, R56, R59, R60, R61, R62, R63, R64, R66, R82, R87, R88, R89, R90, R91, R92, R93: 10k; R_0603_1608Metric
R7, R26, R36, R37, R38, R42, R43, R44, R47, R49, R51, R52, R84, R85, R86, R106, R107, R108, R109: 330; R_0603_1608Metric
R8: 3.9k; R_0603_1608Metric
R9: 680; R_0603_1608Metric
R10: 120; R_0603_1608Metric
R11: 10; R_0603_1608Metric
R12, R13, R18, R19, R28, R29, R30, R31: 1k; R_0603_1608Metric
R20, R21, R22, R23, R32, R33, R34, R35: 100; R_0603_1608Metric
R39, R46, R48, R50, R69, R70, R71, R72, R73, R74, R75, R76, R77, R78, R79, R80, R94, R95, R96, R97, R98, R99, R100, R101, R102, R103, R104, R105: FILTER; R_0603_1608Metric
R58: 7.5k; R_0603_1608Metric
R65, R67, R81: 2.2k; R_0603_1608Metric
SW1: RESET; SW_SPST_PTS810
SW2: TOGGLESW0; 2MS1-T1-B4-VS2-Q-E
SW3: SW0; SW_SPST_PTS810
SW4: SW1; SW_SPST_PTS810
SW5: Control-Power_SW; SW_Micro_SPST
SW6: SW2; SW_SPST_PTS810
SW7: SW3; SW_SPST_PTS810
SW8: EMG_SW; 2MS1-T1-B4-VS2-Q-E
SW9: MAIN_SW; SW_Micro_SPST
SW10: TOGGLESW1; 2MS1-T1-B4-VS2-Q-E
SW11: TOGGLESW2; 2MS1-T1-B4-VS2-Q-E
SW12: TOGGLESW3; 2MS1-T1-B4-VS2-Q-E
U1: MAX3051; SOT-23-8
U2, U10: BD9G101G; TSOP-6_1.65x3.05mm_P0.95mm
U4: AQM0802
U5: AZ1086H; SOT-223-3_TabPin2
U6: STM32F407VG; LQFP-100_14x14mm_P0.5mm
U7: OSTBABS4C2B
U8: ADRESS; rotary_0F
U9: PIC24FJ32GB004; LQFP-44_10x10mm_P0.8mm
U11: CCG30-24-12; CCG30-24-xxS
U12, U13, U14, U15, U16, U17, U19, U20, U21, U22, U23, U24: NCP5104; SOIC-8_3.9x4.9mm_P1.27mm
U18: V23086-C1001; V23086-C1001-A403
U25: LOGO; Mini_Monster
U26: 7805; TO-252-2
U27: TBD62083A; SSOP-18_4.4x6.5mm_P0.65mm
U28: LOGO; Aqualius_Sadalmeric_silk_60x7
U29: LOGO; Aqualius_silk_20.3x15.2_onlyStar
U30: LM7812; TO-252-2
U31: TLP291; SOIC-4_4.55x2.6mm_P1.27mm
Y1: 8MHz; Crystal_SMD_5032_2Pads

Connections (part):
+3V3: C4.1, C7.2, C11.1, C14.1, C16.1, C17.1, C18.1, C21.1, C24.1, C25.2, C26.2, C29.1, C30.1, C36.1, C37.1, C40.1, C79.1, C80.1, D12.1 (K), D14.1 (K), D24.1 (K), ISO1.1 (VDD1), ISO2.1 (VDD1), J1.4 (VDD), J5.1, J5.3, J5.5, J5.7, J5.9, J5.11, J5.13, J5.15, J5.17, J5.19, JP5.2, LS1.1, R7.2, R12.1, R13.1, R18.1, R19.1, R24.2, R25.2, R28.1, R29.1, R30.1, R31.1, R41.2, R42.1, R44.1, R45.2, R54.2, R55.2, R56.2, R66.2, U1.3 (VDD), U4.5 (VDD), U4.9 (/RST), U6.6 (VBAT), U6.11 (VDD), U6.19 (VDD), U6.21 (VREF+), U6.22 (VDDA), U6.28 (VDD), U6.50 (VDD), U6.75 (VDD), U6.100 (VDD), U9.10 (Vusb), U9.17 (AVdd), U9.28 (Vdd), U9.40 (Vdd)
+5P: C38.1, C39.1, C75.1, ISO1.16 (VDD2), ISO2.16 (VDD2), R68.2, U26.3 (VO)
+5V: C9.1, C19.1, C22.2, C23.2, C28.1, C33.2, C34.2, J6.2, J9.2, J11.2, J12.2, J13.2, J14.2, J27.1 (VBUS), JP4.3, Q3.3 (D), R6.2, U5.3 (V_IN), U9.42 (Vbus)
+12P: C44.1, C45.1, C46.1, C47.1, C48.1, C49.1, C62.1, C63.1, C64.1, C65.1, C66.1, C67.1, C74.1, D40.2 (A), D41.2 (A), D42.2 (A), D43.2 (A), D44.2 (A), D45.2 (A), D47.1 (K), D50.2 (A), D51.2 (A), D52.2 (A), D53.2 (A), D54.2 (A), D55.2 (A), R59.1, R60.1, R61.1, R62.1, R63.1, R64.1, R83.2, R88.1, R89.1, R90.1, R91.1, R92.1, R93.1, U12.1 (Vcc), U13.1 (Vcc), U14.1 (Vcc), U15.1 (Vcc), U16.1 (Vcc), U17.1 (Vcc), U19.1 (Vcc), U20.1 (Vcc), U21.1 (Vcc), U22.1 (Vcc), U23.1 (Vcc), U24.1 (Vcc), U26.1 (VI)
+12V: C6.1, C10.1, D16.2 (A), D35.1 (K), J4.2, J7.2, JP4.1, R4.2
+12VA: C87.1, J16.1, U30.3 (VO)
+BATT: D26.1 (K), J23.2, J24.2, J25.1, J25.2, R65.2
/CAN1_RX: U1.4 (RXD), U6.81 (PD0/FSMC_D2/CAN1_RX/EVENTOUT)
/CAN1_TX: U1.1 (TXD), U6.82 (PD1/FSMC_D3/CAN1_TX/EVENTOUT)
/CAN_H: J4.3, J7.3, JP3.1, U1.7 (CANH)
/CAN_L: J4.4, J7.4, R10.2, U1.6 (CANL)
/EMERGENCY_IO: U6.80 (PC12/UART5_TX/SDIO_CK/DCMI_D9/SPI3_MOSI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), U31.1
/FB_Control: C8.2, R8.2, R9.1, U2.3 (FB)
/FB_Control_OUT: C8.1, C20.1, D23.2 (A), L1.2, R8.1
/FB_OUT: C41.2, C59.1, D47.2 (A), L2.2, R58.2
/MCLR: J28.1, R41.1, U9.18 (MCLR)
/MOTOR0L_PWM: ISO1.15 (B1), U12.2 (IN)
/MOTOR0R_PWM: ISO1.14 (B2), U13.2 (IN)
/MOTOR1L_PWM: ISO1.13 (B3), U14.2 (IN)
/MOTOR1R_PWM: ISO1.12 (B4), U15.2 (IN)
/MOTOR2L_PWM: ISO1.11 (B5), U16.2 (IN)
/MOTOR2R_PWM: ISO1.10 (B6), U17.2 (IN)
/MOTOR3L_PWM: ISO2.15 (B1), U19.2 (IN)
/MOTOR3R_PWM: ISO2.14 (B2), U20.2 (IN)
/MOTOR4L_PWM: ISO2.13 (B3), U21.2 (IN)
/MOTOR4R_PWM: ISO2.12 (B4), U22.2 (IN)
/MOTOR5L_PWM: ISO2.11 (B5), U23.2 (IN)
/MOTOR5R_PWM: ISO2.10 (B6), U24.2 (IN)
/Motor0L: C5.1, C53.2, J17.1, Q5.1 (S1), Q5.5 (D2_1), Q5.6 (D2_2), Q5.11 (D2_3), Q5.12 (D2_4), Q5.13 (D2_5), U12.6 (BRIDGE)
/Motor0R: C5.2, C54.2, J17.2, Q6.1 (S1), Q6.5 (D2_1), Q6.6 (D2_2), Q6.11 (D2_3), Q6.12 (D2_4), Q6.13 (D2_5), U13.6 (BRIDGE)
/Motor1L: C55.2, C81.1, J18.1, Q7.1 (S1), Q7.5 (D2_1), Q7.6 (D2_2), Q7.11 (D2_3), Q7.12 (D2_4), Q7.13 (D2_5), U14.6 (BRIDGE)
/Motor1R: C56.2, C81.2, J18.2, Q8.1 (S1), Q8.5 (D2_1), Q8.6 (D2_2), Q8.11 (D2_3), Q8.12 (D2_4), Q8.13 (D2_5), U15.6 (BRIDGE)
/Motor2L: C57.2, C82.1, J19.1, Q9.1 (S1), Q9.5 (D2_1), Q9.6 (D2_2), Q9.11 (D2_3), Q9.12 (D2_4), Q9.13 (D2_5), U16.6 (BRIDGE)
/Motor2R: C58.2, C82.2, J19.2, Q10.1 (S1), Q10.5 (D2_1), Q10.6 (D2_2), Q10.11 (D2_3), Q10.12 (D2_4), Q10.13 (D2_5), U17.6 (BRIDGE)
/Motor3L: C68.2, C83.1, J20.1, Q16.1 (S1), Q16.5 (D2_1), Q16.6 (D2_2), Q16.11 (D2_3), Q16.12 (D2_4), Q16.13 (D2_5), U19.6 (BRIDGE)
/Motor3R: C69.2, C83.2, J20.2, Q17.1 (S1), Q17.5 (D2_1), Q17.6 (D2_2), Q17.11 (D2_3), Q17.12 (D2_4), Q17.13 (D2_5), U20.6 (BRIDGE)
/Motor4L: C70.2, C84.1, J21.1, Q12.1 (S1), Q12.5 (D2_1), Q12.6 (D2_2), Q12.11 (D2_3), Q12.12 (D2_4), Q12.13 (D2_5), U21.6 (BRIDGE)
/Motor4R: C71.2, C84.2, J21.2, Q13.1 (S1), Q13.5 (D2_1), Q13.6 (D2_2), Q13.11 (D2_3), Q13.12 (D2_4), Q13.13 (D2_5), U22.6 (BRIDGE)
/Motor5L: C72.2, C85.1, J22.1, Q14.1 (S1), Q14.5 (D2_1), Q14.6 (D2_2), Q14.11 (D2_3), Q14.12 (D2_4), Q14.13 (D2_5), U23.6 (BRIDGE)
/Motor5R: C73.2, C85.2, J22.2, Q15.1 (S1), Q15.5 (D2_1), Q15.6 (D2_2), Q15.11 (D2_3), Q15.12 (D2_4), Q15.13 (D2_5), U24.6 (BRIDGE)
/OSC_IN: C1.1, U6.12 (PH0/OSC_IN/EVENTOUT), Y1.1
/OSC_OUT: C3.1, U6.13 (PH1/OSC_OUT/EVENTOUT), Y1.2
/PA0_TIM5_CH1: R20.1, U6.23 (PA0/WKUP/USART2_CTS/UART4_TX/ETH_MII_CR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)
/PA1_TIM5_CH2: R22.1, U6.24 (PA1/USART2_RTS/UART4_RX/ETH_RMII_REF_CL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)
/PA2_ADC12_IN2: J2.5, U6.25 (PA2/USART2_TX/TIM5_CH3/TIM9_CH1/TIM2_CH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)
/PA3_ADC12_IN3: J2.6, U6.26 (PA3/USART2_RX/TIM5_CH4/TIM9_CH2/TIM2_CH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)
/PA4_SPI1_NSS: R46.2, U6.29 (PA4/SPI1_NSS/SPI3_NSS/USART2_CK/DCMI_HS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)
/PA5_SPI1_SCK: R50.2, U6.30 (PA5/SPI1_SCK/OTG_HS_ULPI_CK/TIM2_CH1_ET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)
/PA6_SPI1_MISO: R39.2, U6.31 (PA6/SPI1_MISO/TIM8_BKIN/TIM13_CH1/DCMI_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)
/PA7_SPI1_MOSI: R48.2, U6.32 (PA7/SPI1_MOSI/TIM8_CH1N/TIM14_CH1/TIM3_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)
/PA8_BLUE: R36.1, U6.67 (PA8/MCO1/USART1_CK/TIM1_CH1/I2C3_SCL/OT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)
/PA9_USART1_TX: U6.68 (PA9/USART1_TX/TIM1_CH2/I2C3_SMBA/DCMI_D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), U9.3 (RP23_CN17_RC7)
/PA10_USART1_RX: U6.69 (PA10/USART1_RX/TIM1_CH3/OTG_FS_ID/DCMI_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), U9.2 (RP22_CN18_RC6)
/PA11_LED4: R51.2, U6.70 (PA11/USART1_CTS/CAN1_RX/TIM1_CH4_/OTG_F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)
/PA12_LED3: R49.2, U6.71 (PA12/USART1_RTS/CAN1_TX/TIM1_ETR/OTG_FS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)
/PA15_TIM2_CH1: R32.1, U6.77 (PA15/JTDI/SPI3_NSS/I2S3_WS/TIM2_CH1_ETR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)
/PB0_ADC12_IN8: J2.9, U6.35 (PB0/TIM3_CH3/TIM8_CH2N/OTG_HS_ULPI_D1/E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)
/PB1_ADC12_IN9: J2.10, U6.36 (PB1/TIM3_CH4/TIM8_CH3N/OTG_HS_ULPI_D2/E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)
/PB2_SW0: R54.1, SW3.2, U6.37 (PB2/BOOT1/EVENTOUT)
/PB3_TIM2_CH2: R34.1, U6.89 (PB3/JTDO/TRACESWO/SPI3_SCK/I2S3_CK/TIM2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)
/PB4_TIM3_CH1: R21.1, U6.90 (PB4/NJTRST/SPI3_MISO/TIM3_CH1/SPI1_MISO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)
/PB5_TIM3_CH2: R23.1, U6.91 (PB5/I2C1_SMBA/CAN2_RX/OTG_HS_ULPI_D7/ET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)
/PB6_I2C1_SCL: R25.1, U4.8 (SCL), U6.92 (PB6/I2C1_SCL/TIM4_CH1/CAN2_TX/DCMI_D5/U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)
/PB7_I2C1_SDA: R24.1, U4.7 (SDA), U6.93 (PB7/I2C1_SDA/FSMC_NL/DCMI_VSYNC/USART1_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)
/PB8_Buzzer_TIM10_CH1: Q1.1 (B), U6.95 (PB8/TIM4_CH3/SDIO_D4/TIM10_CH1/DCMI_D6/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)
/PB9_SD_Connection: J1.9 (DET_B), R45.1, U6.96 (PB9/SPI2_NSS/I2S2_WS/TIM4_CH4/TIM11_CH1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)
/PB10_RED: R38.1, U6.47 (PB10/SPI2_SCK/I2S2_CK/I2C2_SCL/USART3_T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)
/PB11_GREEN: R37.1, U6.48 (PB11/I2C2_SDA/USART3_RX/OTG_HS_ULPI_D4/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)
/PB12_ADRESS2: U6.51 (PB12/SPI2_NSS/I2S2_WS/I2C2_SMBA/USART3_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), U8.4
/PB13_ADRESS3: U6.52 (PB13/SPI2_SCK/I2S2_CK/USART3_CTS/TIM1_C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), U8.6 (8)
/PC0_ADC12_IN10: J2.1, U6.15 (PC0/OTG_HS_ULPI_STP/EVENTOUT)
/PC1_ADC12_IN11: J2.2, U6.16 (PC1/ETH_MDC/_EVENTOUT)
/PC2_ADC12_IN12: J2.3, U6.17 (PC2/SPI2_MISO/OTG_HS_ULPI_DIR/ETH_MII_T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)
/PC3_ADC12_IN13: J2.4, U6.18 (PC3/SPI2_MOSI/I2S2_SD/OTG_HS_ULPI_NXT/E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)
/PC4_ADC12_IN14: J2.7, U6.33 (PC4/ETH_RMII_RX_D0/ETH_MII_RX_D0/EVENTO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)
/PC5_ADC12_IN15: J2.8, U6.34 (PC5/ETH_RMII_RX_D1/ETH_MII_RX_D1/EVENTO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)
/PC10_LED2: R47.2, U6.78 (PC10/SPI3_SCK/I2S3_CK/UART4_TX/SDIO_D2/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)
/PC11_LED1: R43.2, U6.79 (PC11/UART4_RX/SPI3_MISO/SDIO_D3/DCMI_D4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)
/PC13_IO: R109.2, U6.7 (PC13/EVENTOUT), U27.8 (IN8)
/PC14_IO: R108.2, U6.8 (PC14/OSC32_IN/EVENTOUT), U27.7 (IN7)
/PC15_IO: R107.2, U6.9 (PC15/OSC32_OUT/EVENTOUT), U27.6 (IN6)
/PD2_DIPSW_0: U6.83 (PD2/TIM3_ETR/UART5_RX/SDIO_CMD/DCMI_D11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)
/PD3_DIPSW_1: U6.84 (PD3/FSMC_CLK/USART2_CTS/EVENTOUT)
/PD4_DIPSW_2: U6.85 (PD4/FSMC_NOE/USART2_RTS/EVENTOUT)
/PD5_USART2_TX: J9.3, U6.86 (PD5/FSMC_NWE/USART2_TX/EVENTOUT)
/PD6_USART2_RX: J9.4, U6.87 (PD6/FSMC_NWAIT/USART2_RX/EVENTOUT)
/PD7_DIPSW_3: U6.88 (PD7/USART2_CK/FSMC_NE1/FSMC_NCE2/EVENTO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)
/PD8_USART3_TX: J6.3, U6.55 (PD8/FSMC_D13/USART3_TX/EVENTOUT)
/PD9_USART3_RX: J6.4, U6.56 (PD9/FSMC_D14/USART3_RX/EVENTOUT)
/PD10_TOGGLESW_0: SW2.2 (B), U6.57 (PD10/FSMC_D15/USART3_CK/EVENTOUT)
/PD11_TOGGLESW_1: SW10.2 (B), U6.58 (PD11/FSMC_CLE/FSMC_A16/USART3_CTS/EVENT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)
/PD12_TIM4_CH1: R33.1, U6.59 (PD12/FSMC_ALE/FSMC_A17/TIM4_CH1/USART3_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)
/PD13_TIM4_CH2: R35.1, U6.60 (PD13/FSMC_A18/TIM4_CH2/EVENTOUT)
/PD14_TOGGLESW_2: SW11.2 (B), U6.61 (PD14/FSMC_D0/TIM4_CH3/EVENTOUT/_EVENTOUT)
/PD15_TOGGLESW_3: SW12.2 (B), U6.62 (PD15/FSMC_D1/TIM4_CH4/EVENTOUT)
/PE0_IO: R26.2, U6.97 (PE0/TIM4_ETR/FSMC_NBL0/DCMI_D2/EVENTOUT), U27.1 (IN1)
/PE1_IO: R84.2, U6.98 (PE1/FSMC_NBL1/DCMI_D3/EVENTOUT), U27.2 (IN2)
/PE2_IO: R85.2, U6.1 (PE2/TRACECLK/FSMC_A23/ETH_MII_TXD3/EVEN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), U27.3 (IN3)
/PE3_IO: R86.2, U6.2 (PE3/TRACED0/FSMC_A19/EVENTOUT), U27.4 (IN4)
/PE4_IO: R106.2, U6.3 (PE4/TRACED1/FSMC_A20/DCMI_D4/EVENTOUT), U27.5 (IN5)
/PE7_SW3: R66.1, SW7.2, U6.38 (PE7/FSMC_D4/TIM1_ETR/EVENTOUT)
/PE8_ADRESS0: U6.39 (PE8/FSMC_D5/TIM1_CH1N/EVENTOUT), U8.3 (1)
/PE10_ADRESS1: U6.41 (PE10/FSMC_D7/TIM1_CH2N/EVENTOUT), U8.1 (2)
/PE12_SW2: R56.1, SW6.2, U6.43 (PE12/FSMC_D9/TIM1_CH3N/EVENTOUT)
/PE15_SW1: R55.1, SW4.2, U6.46 (PE15/FSMC_D12/TIM1_BKIN/EVENTOUT)
/PGEC1: J28.5, U9.22 (PGEDC1_AN3_C2INA_RP1_CN5_RB1)
/PGED1: J28.4, U9.21 (PGED1_AN2_C2INB_RP0_CN4_RB0)
/SWCLK: J3.3, U6.76 (PA14/JTCK/SWCLK/EVENTOUT)
/SWDIO: J3.4, U6.72 (PA13/JTMS/SWDIO/EVENTOUT)
/USB_A_D+: J27.3 (D+), U9.8 (PGED2_D+_RP10_CN16_RB10)
/USB_A_D-: J27.2 (D-), U9.9 (PGEC2_D-_RP11_CN15_RB11)
/motor0_L_signal: ISO1.2 (A1), U6.4 (PE5/TRACED2/FSMC_A21/TIM9_CH1/DCMI_D6/E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)
/motor0_R_signal: ISO1.3 (A2), U6.5 (PE6/TRACED3_/_FSMC_A22/TIM9_CH2/DCMI_D7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)
/motor1_L_signal: ISO1.4 (A3), U6.66 (PC9/I2S_CKIN/MCO2/TIM8_CH4/SDIO_D1/I2C3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)
/motor1_R_signal: ISO1.5 (A4), U6.65 (PC8/TIM8_CH3/SDIO_D0/TIM3_CH3/USART6_CK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)
/motor2_L_signal: ISO1.6 (A5), U6.64 (PC7/I2S3_MCK/TIM8_CH2/SDIO_D7/USART6_RX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)
/motor2_R_signal: ISO1.7 (A6), U6.63 (PC6/I2S2_MCK/TIM8_CH1/SDIO_D6/USART6_TX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)
/motor3_L_signal: ISO2.2 (A1), U6.54 (PB15/SPI2_MOSI/I2S2_SD/TIM1_CH3N/TIM8_C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)
/motor3_R_signal: ISO2.3 (A2), U6.53 (PB14/SPI2_MISO/TIM1_CH2N/TIM12_CH1/OTG_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)
/motor4_L_signal: ISO2.4 (A3), U6.45 (PE14/FSMC_D11/TIM1_CH4/EVENTOUT)
/motor4_R_signal: ISO2.5 (A4), U6.44 (PE13/FSMC_D10/TIM1_CH3/EVENTOUT)
/motor5_L_signal: ISO2.6 (A5), U6.42 (PE11/FSMC_D8/TIM1_CH2/EVENTOUT)
/motor5_R_signal: ISO2.7 (A6), U6.40 (PE9/FSMC_D6/TIM1_CH1/EVENTOUT)
/~RST: C2.2, J3.5, SW1.1, U6.14 (NRST)
Batt: C52.1, D25.2 (A), Q2.3 (D), R67.2, U11.3 (+Vin)
Control_5V: D34.1 (K), Q3.2 (S), Q4.3 (D), R3.2, R27.2
External_5V: D34.2 (A), J15.2, Q4.1 (G), R1.2, R53.2
GND: C1.2, C2.1, C3.2, C4.2, C6.2, C7.1, C9.2, C10.2, C11.2, C12.1, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.1, C23.1, C24.2, C25.1, C28.2, C29.2, C30.2, C31.2, C32.2, C33.1, C34.1, C35.2, C36.2, C37.2, C40.2, C42.2, C78.2, C79.2, C80.2, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D13.1 (K), D20.2 (A), D21.1 (K), D22.1 (K), D28.1 (K), D29.1 (K), D30.1 (K), D31.1 (K), ISO1.8 (GND1), ISO2.8 (GND1), J1.6 (VSS), J1.10 (DET_A), J3.1, J4.1, J5.2, J5.4, J5.6, J5.8, J5.10, J5.12, J5.14, J5.16, J5.18, J5.20, J6.1, J7.1, J9.1, J10.2, J10.4, J10.6, J10.8, J10.10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
GNDPWR: C38.2, C39.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, C59.2, C60.2, C61.2, C62.2, C63.2, C64.2, C65.2, C66.2, C67.2, C74.2, C75.2, C76.2, C77.2, C86.2, C87.2, D36.1 (K), D38.1 (K), D39.2 (A), D46.1 (K), D48.1 (K), D57.1 (K), ISO1.9 (GND2), ISO2.9 (GND2), J23.1, J24.1, Q5.3 (S2), Q6.3 (S2), Q7.3 (S2), Q8.3 (S2), Q9.3 (S2), Q10.3 (S2), Q11.2 (S), Q12.3 (S2), Q13.3 (S2), Q14.3 (S2), Q15.3 (S2), Q16.3 (S2), Q17.3 (S2), R57.2, R82.2, R87.2, SW8.3 (C), U10.2 (GND), U11.1 (RC), U11.2 (-Vin), U12.4 (GND), U13.4 (GND), U14.4 (GND), U15.4 (GND), U16.4 (GND), U17.4 (GND), U19.4 (GND), U20.4 (GND), U21.4 (GND), U22.4 (GND), U23.4 (GND), U24.4 (GND), U26.2 (GND), U30.2 (GND)
MOTOR_Batt: C50.1, C51.1, C60.1, C61.1, C76.1, C77.1, Q5.7 (D1_1), Q5.8 (D1_2), Q5.9 (D1_3), Q5.10 (D1_4), Q5.14 (D1_5), Q6.7 (D1_1), Q6.8 (D1_2), Q6.9 (D1_3), Q6.10 (D1_4), Q6.14 (D1_5), Q7.7 (D1_1), Q7.8 (D1_2), Q7.9 (D1_3), Q7.10 (D1_4), Q7.14 (D1_5), Q8.7 (D1_1), Q8.8 (D1_2), Q8.9 (D1_3), Q8.10 (D1_4), Q8.14 (D1_5), Q9.7 (D1_1), Q9.8 (D1_2), Q9.9 (D1_3), Q9.10 (D1_4), Q9.14 (D1_5), Q10.7 (D1_1), Q10.8 (D1_2), Q10.9 (D1_3), Q10.10 (D1_4), Q10.14 (D1_5), Q12.7 (D1_1), Q12.8 (D1_2), Q12.9 (D1_3), Q12.10 (D1_4), Q12.14 (D1_5), Q13.7 (D1_1), Q13.8 (D1_2), Q13.9 (D1_3), Q13.10 (D1_4), Q13.14 (D1_5), Q14.7 (D1_1), Q14.8 (D1_2), Q14.9 (D1_3), Q14.10 (D1_4), Q14.14 (D1_5), Q15.7 (D1_1), Q15.8 (D1_2), Q15.9 (D1_3), Q15.10 (D1_4), Q15.14 (D1_5), Q16.7 (D1_1), Q16.8 (D1_2), Q16.9 (D1_3), Q16.10 (D1_4), Q16.14 (D1_5), Q17.7 (D1_1), Q17.8 (D1_2), Q17.9 (D1_3), Q17.10 (D1_4), Q17.14 (D1_5), R81.2, U10.4 (EN), U10.5 (VCC), U18.5 (N.O)
unnamed: C13.1, D20.1 (K), L1.1, U2.6 (SW)
unnamed: C13.2, U2.1 (BS)
unnamed: C15.1, D16.1 (K), U2.4 (EN), U2.5 (IN)
unnamed: C26.1, U4.2 (VOUT)
unnamed: C27.1, U4.3 (CAP1N)
unnamed: C27.2, U4.4 (CAP1P)
unnamed: C31.1, D24.2 (A), U5.2 (V_OUT)
unnamed: C32.1, U6.49 (VCAP_1)
unnamed: C35.1, U6.73 (VCAP_2)
unnamed: C41.1, R57.1, R58.1, U10.3 (FB)
unnamed: C42.1, D35.2 (A), U11.6 (+Vout)
unnamed: C43.1, D39.1 (K), L2.1, U10.6 (Lx)
unnamed: C43.2, U10.1 (BST)
unnamed: C53.1, D40.1 (K), U12.8 (VBOOT)
unnamed: C54.1, D41.1 (K), U13.8 (VBOOT)
unnamed: C55.1, D42.1 (K), U14.8 (VBOOT)
unnamed: C56.1, D43.1 (K), U15.8 (VBOOT)
unnamed: C57.1, D44.1 (K), U16.8 (VBOOT)
unnamed: C58.1, D45.1 (K), U17.8 (VBOOT)
unnamed: C68.1, D50.1 (K), U19.8 (VBOOT)
unnamed: C69.1, D51.1 (K), U20.8 (VBOOT)
unnamed: C70.1, D52.1 (K), U21.8 (VBOOT)
unnamed: C71.1, D53.1 (K), U22.8 (VBOOT)
unnamed: C72.1, D54.1 (K), U23.8 (VBOOT)
unnamed: C73.1, D55.1 (K), U24.8 (VBOOT)
unnamed: C78.1, U9.7 (Vcap_VddCore)
unnamed: C86.1, D25.1 (K), U30.1 (VI)
unnamed: D1.2 (A), R26.1
unnamed: D2.2 (A), R84.1
unnamed: D3.2 (A), R1.1
unnamed: D4.2 (A), R2.1
unnamed: D5.2 (A), R3.1
unnamed: D6.2 (A), R4.1
unnamed: D7.2 (A), R85.1
unnamed: D8.2 (A), R6.1
unnamed: D9.2 (A), R7.1
unnamed: D10.2 (A), R86.1
unnamed: D11.2 (A), R106.1
unnamed: D12.2 (A), JP1.2
unnamed: D13.2 (A), R107.1
unnamed: D14.2 (A), LS1.2, R11.2
unnamed: D21.2 (A), R108.1
unnamed: D22.2 (A), R109.1
unnamed: D26.2 (A), Q2.2 (S), SW9.2 (B)
unnamed: D28.2 (A), R43.1
unnamed: D29.2 (A), R47.1
unnamed: D30.2 (A), R49.1
unnamed: D31.2 (A), R51.1
unnamed: D33.1 (K), Q4.2 (S)
unnamed: D36.2 (A), R65.1
unnamed: D37.1 (K), U9.14 (AN10_C3INB_CVref_VBUSON_RP14_CN12_RB14)
unnamed: D37.2 (A), R42.2
unnamed: D38.2 (A), R67.1
unnamed: D46.2 (A), R68.1
unnamed: D48.2 (A), R81.1
unnamed: D49.1 (K), U9.15 (AN9_C3INA_VBUSCHG_RP15_CN11_RB15)
unnamed: D49.2 (A), R44.2
unnamed: D56.1 (K), Q18.3 (D), U18.1, U31.4
unnamed: D56.2 (A), Q11.3 (D), U18.2
unnamed: D57.2 (A), R83.1
unnamed: D58.1 (K), JP5.1
unnamed: D58.2 (A), J28.2
unnamed: J1.2 (DAT3/CD), R46.1
unnamed: J1.3 (CMD), R48.1
unnamed: J1.5 (CLK), R50.1
unnamed: J1.7 (DAT0), R39.1
unnamed: J3.2, JP1.1
unnamed: J8.1, U27.18 (OUT1)
unnamed: J8.2, U27.17 (OUT2)
unnamed: J8.3, U27.16 (OUT3)
unnamed: J8.4, U27.15 (OUT4)
unnamed: J8.5, U27.14 (OUT5)
unnamed: J8.6, U27.13 (OUT6)
unnamed: J8.7, U27.12 (OUT7)
unnamed: J8.8, U27.11 (OUT8)
unnamed: J11.3, R18.2, R22.2
unnamed: J11.4, R12.2, R20.2
unnamed: J12.3, R19.2, R23.2
unnamed: J12.4, R13.2, R21.2
unnamed: J13.3, R30.2, R34.2
unnamed: J13.4, R28.2, R32.2
unnamed: J14.3, R31.2, R35.2
unnamed: J14.4, R29.2, R33.2
unnamed: J16.2, Q18.2 (S), R40.1
unnamed: JP3.2, R10.1
unnamed: Q1.3 (C), R11.1
unnamed: Q2.1 (G), R82.1, SW9.1 (A)
unnamed: Q3.1 (G), R27.1, SW5.2 (B)
unnamed: Q5.2 (G1), R69.1
unnamed: Q5.4 (G2), R70.1
unnamed: Q6.2 (G1), R71.1
unnamed: Q6.4 (G2), R72.1
unnamed: Q7.2 (G1), R73.1
unnamed: Q7.4 (G2), R74.1
unnamed: Q8.2 (G1), R75.1
unnamed: Q8.4 (G2), R76.1
unnamed: Q9.2 (G1), R77.1
unnamed: Q9.4 (G2), R78.1
unnamed: Q10.2 (G1), R79.1
unnamed: Q10.4 (G2), R80.1
unnamed: Q11.1 (G), R87.1, U31.3
unnamed: Q12.2 (G1), R98.1
unnamed: Q12.4 (G2), R99.1
unnamed: Q13.2 (G1), R100.1
unnamed: Q13.4 (G2), R101.1
unnamed: Q14.2 (G1), R102.1
unnamed: Q14.4 (G2), R103.1
unnamed: Q15.2 (G1), R104.1
unnamed: Q15.4 (G2), R105.1
unnamed: Q16.2 (G1), R94.1
unnamed: Q16.4 (G2), R95.1
unnamed: Q17.2 (G1), R96.1
unnamed: Q17.4 (G2), R97.1
unnamed: Q18.1 (G), R40.2, SW8.2 (B)
unnamed: R5.1, U6.94 (BOOT0)
unnamed: R36.2, U7.1 (blue_A)
unnamed: R37.2, U7.2 (green_A)
unnamed: R38.2, U7.3 (red_A)
unnamed: R52.2, U31.2
unnamed: R59.2, U13.3 (~SD)
unnamed: R60.2, U15.3 (~SD)
unnamed: R61.2, U17.3 (~SD)
unnamed: R62.2, U12.3 (~SD)
unnamed: R63.2, U14.3 (~SD)
unnamed: R64.2, U16.3 (~SD)
unnamed: R69.2, U12.7 (DRV_HO)
unnamed: R70.2, U12.5 (DRV_LO)
unnamed: R71.2, U13.7 (DRV_HO)
unnamed: R72.2, U13.5 (DRV_LO)
unnamed: R73.2, U14.7 (DRV_HO)
unnamed: R74.2, U14.5 (DRV_LO)
unnamed: R75.2, U15.7 (DRV_HO)
unnamed: R76.2, U15.5 (DRV_LO)
unnamed: R77.2, U16.7 (DRV_HO)
unnamed: R78.2, U16.5 (DRV_LO)
unnamed: R79.2, U17.7 (DRV_HO)
unnamed: R80.2, U17.5 (DRV_LO)
unnamed: R88.2, U20.3 (~SD)
unnamed: R89.2, U22.3 (~SD)
unnamed: R90.2, U24.3 (~SD)
unnamed: R91.2, U19.3 (~SD)
unnamed: R92.2, U21.3 (~SD)
unnamed: R93.2, U23.3 (~SD)
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