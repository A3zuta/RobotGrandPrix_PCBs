# Repository A3zuta/RobotGrandPrix_PCBs (continued)

## KiCad design Aqualius_Sadalsuud_for_KITRP/Main.kicad_pcb (continued)

Board: 2 copper layers, 100.0 x 100.0 mm, 341 parts (172 on the bottom side), 284 nets.

## KiCad design 2020/Robot_Rancer/Sagittarius_Alnasl/Aloe_Set_Meal.kicad_pcb

Parts:
C1, C4: 22p; C_0603_1608Metric
C2, C3, C6, C10, C12, C14, C15, C16, C44, C45, C46, C50, C51, C52, C53, C54, C57, C58, C59, C60, C61: 0.1u; C_0603_1608Metric
C5, C9: 4.7u; C_0603_1608Metric
C7: 2.2u; C_0603_1608Metric
C8, C11, C25, C26, C27, C28, C29, C30, C37, C38, C39, C40, C41, C42, C48, C49: 4.7u; C_0805_2012Metric
C13: 10u; C_0805_2012Metric
C17, C55, C56: 1u; C_0603_1608Metric
C18: 22u; C_0603_1608Metric
C19, C20, C21, C22, C23, C24, C31, C32, C33, C34, C35, C36: 0.1u; 1608_WP
C43, C47: 470u; CAPAE1300X1400N
D1, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D27, D28, D29, D30: DIODE; D_SOD-123
D2, D3, D4: LED; LED_0603_1608Metric
D22: BATT; LED_0603_1608Metric
D23: MAIN_BATT; LED_0603_1608Metric
D24: MOTOR_BATT; LED_0603_1608Metric
D25: 5V; LED_0603_1608Metric
D26: 3.3V; LED_0603_1608Metric
D31: 5V_dcdc; LED_0603_1608Metric
J1: SWD; PinHeader_1x06_P2.54mm_Vertical
J2: ADC; PinHeader_1x10_P2.54mm_Vertical
J3: ADC_Vdd; PinHeader_2x10_P2.54mm_Vertical
J4: SERIAL0; USB_Micro-B_Molex_47346-0001
J5: ENC; XA_4P
J6: MOTOR0; XT30_F
J7: MOTOR2; XT30_F
J8: MOTOR4; XT30_F
J9: SERVO; PinHeader_1x03_P2.54mm_Vertical
J10: MOTOR1; XT30_F
J11: MOTOR3; XT30_F
J12: MOTOR5; XT30_F
J13: BATT_IN; XT60_M
J14: 3522-2; Manufacturer_Part_Number 3522-2
J15: microSD; microSD_HC_Hirose_DM3AT-SF-PEJM5
J16: SERIAL1; XA_4P
J17: VOLTMETER; V_BattMeter
J18: TO_VOLTMETER; XA_2LC
JP1: SWD_3.3V_JP; PinHeader_1x02_P2.54mm_Vertical
JP2: Relay_JP; PinHeader_1x02_P2.54mm_Vertical
L1: 22uH; Inductor_Taiyo-Yuden_NR-60xx
LS1: Speaker; UGCT7525AN4
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8, Q9, Q10, Q11, Q12: NVMFD5C446NLT1G; NVMFD5C446NLWFT1G; Mouser Part Number 863-NVMFD5C446NLT1G
Q13, Q15: FET_P; SOT-23
Q14: FET_N; SOT-23W
Q16: NPN; SOT-23W
R1: 680; R_0603_1608Metric
R2, R3, R8, R9, R52, R58, R59, R60, R65, R68, R69: 10k; R_0603_1608Metric
R4: 3.9k; R_0603_1608Metric
R5, R6, R7, R10, R11, R57, R71: 330; R_0603_1608Metric
R12, R13: 1k; R_0603_1608Metric
R14, R15: 4.7k; R_0603_1608Metric
R16, R17, R18, R19, R20, R21, R34, R35, R36, R37, R38, R39: 10k; 1608_WP
R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32, R33, R40, R41, R42, R43, R44, R45, R46, R47, R48, R49, R50, R51, R66: 10; R_0603_1608Metric
R53, R54, R55: 2.2k; R_0603_1608Metric
R56, R70: 510; R_0603_1608Metric
R61, R62, R63, R64: FILTER; R_0603_1608Metric
R67: 120; R_0603_1608Metric
SW1: RST; SW_SPST_CK_RS282G05A3
SW2: SW0; SW_SPST_CK_RS282G05A3
SW3: SW1; SW_SPST_CK_RS282G05A3
SW4: EMG; 2MS1-T1-B4-VS2-Q-E
SW5: MAIN_SW; 2MS1-T1-B4-VS2-Q-E
U1: BD9G101G; TSOP-6_1.65x3.05mm_P0.95mm
U2: MCP2221A; SOIC-14_3.9x8.7mm_P1.27mm
U3: STM32F446RETx; LQFP-64_10x10mm_P0.5mm
U4: ROTARY; rotary_0F
U5: AZ1086H; SOT-223-3_TabPin2
U6, U7, U8, U9, U10, U11, U12, U13, U14, U15, U16, U17: NCP5104; SOIC-8_3.9x4.9mm_P1.27mm
U18: V23086-C1001; V23086-C1001-A403
U19: LOGO; Mini_Monster
U20: LOGO; Sagittarius_Alnasl_silk_40.0x11.4
U21: LOGO; Goukazal_15.0x11.3_S.Itoh_silk
U22: AQM0802
U23: 74HCT04; SOIC-14_3.9x8.7mm_P1.27mm
U24, U25, U26: 74HC02; SOIC-14_3.9x8.7mm_P1.27mm
U27: LOGO; AloeSetMeal_Mask_50x5.8
U28: FULLCOLOR; OSTBABS4C2B
U29: LOGO; ARM_mbed_50x27.5_silk
U30: LOGO; STmicro_logo_silk_20x13
U31: LOGO; kodani_miconCar_30x19_silk
Y1: 8MHz; Crystal_SMD_5032_2Pads

Connections:
5Vc: D7.1 (K), Q13.2 (S), R65.1, R70.2
+3V3: C3.1, C9.1, C10.1, C12.1, C14.1, C16.1, C17.1, C18.1, C54.2, C55.2, C58.1, C59.1, C60.1, C61.1, D1.1 (K), D28.1 (K), J3.1, J3.3, J3.5, J3.7, J3.9, J3.11, J3.13, J3.15, J3.17, J3.19, J15.4 (VDD), LS1.1, R2.1, R3.1, R5.2, R6.2, R7.2, R9.2, R57.2, R68.1, R69.1, U2.1 (Vdd), U2.11 (Vusb), U3.1 (VBAT), U3.13 (VDDA), U3.19 (VDD), U3.32 (VDD), U3.48 (VDD), U3.64 (VDD), U5.2 (V_OUT), U22.5 (VDD), U22.9 (/RST), U23.14 (VCC), U24.14 (VCC), U25.14 (VCC), U26.14 (VCC)
+5V: C13.1, C15.2, C53.2, D8.1 (K), J5.2, J16.2, Q13.3 (D), R12.1, R13.1, R56.2, U5.3 (V_IN)
+BATT: D21.2 (A), D29.2 (A), J13.2, J14.1, J14.2, R53.2
/ADC0: J2.1, U3.8 (PC0)
/ADC1: J2.2, U3.9 (PC1)
/ADC2: J2.3, U3.10 (PC2)
/ADC3: J2.4, U3.11 (PC3)
/ADC4: J2.5, U3.14 (PA0)
/ADC5: J2.6, U3.20 (PA4)
/ADC6: J2.7, U3.21 (PA5)
/ADC7: J2.8, U3.24 (PC4)
/ADC8: J2.9, U3.25 (PC5)
/ADC9: J2.10, U3.26 (PB0)
/ADRESS0: U3.56 (PB4), U4.3 (1)
/ADRESS1: U3.57 (PB5), U4.1 (2)
/ADRESS2: U3.55 (PB3), U4.4
/ADRESS3: U3.54 (PD2), U4.6 (8)
/Batt: C8.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C31.1, C32.1, C33.1, C34.1, C35.1, C36.1, D9.2 (A), D10.2 (A), D11.2 (A), D12.2 (A), D13.2 (A), D14.2 (A), D15.2 (A), D16.2 (A), D17.2 (A), D18.2 (A), D19.2 (A), D20.2 (A), D21.1 (K), Q15.2 (S), R16.2, R17.2, R18.2, R19.2, R20.2, R21.2, R34.2, R35.2, R36.2, R37.2, R38.2, R39.2, R52.1, R54.2, U1.4 (EN), U1.5 (VCC), U6.1 (Vcc), U7.1 (Vcc), U8.1 (Vcc), U9.1 (Vcc), U10.1 (Vcc), U11.1 (Vcc), U12.1 (Vcc), U13.1 (Vcc), U14.1 (Vcc), U15.1 (Vcc), U16.1 (Vcc), U17.1 (Vcc)
/Buzzer_PWM: R66.2, U3.15 (PA1)
/D+: J4.3 (D+), U2.13 (D+)
/D-: J4.2 (D-), U2.12 (D-)
/EMG_IO: Q14.1 (G), R58.1, U3.45 (PA12)
/ENC_CH1: R14.2, R59.1, U3.22 (PA6)
/ENC_CH2: R15.2, R60.1, U3.23 (PA7)
/FB: C5.2, C11.1, D7.2 (A), L1.2, R4.2
/I2C2_SCL: R68.2, U3.29 (PB10), U22.8 (SCL)
/I2C2_SDA: R69.2, U3.53 (PC12), U22.7 (SDA)
/LED_Blue: R10.2, U3.4 (PC15)
/LED_Green: R11.2, U3.3 (PC14)
/LED_Red: R71.2, U3.2 (PC13)
/MOTOR_BATT: C43.1, C47.1, C48.1, C49.1, C57.2, J9.2, Q1.7 (D1_1), Q1.8 (D1_2), Q1.9 (D1_3), Q1.10 (D1_4), Q1.14 (D1_5), Q2.7 (D1_1), Q2.8 (D1_2), Q2.9 (D1_3), Q2.10 (D1_4), Q2.14 (D1_5), Q3.7 (D1_1), Q3.8 (D1_2), Q3.9 (D1_3), Q3.10 (D1_4), Q3.14 (D1_5), Q4.7 (D1_1), Q4.8 (D1_2), Q4.9 (D1_3), Q4.10 (D1_4), Q4.14 (D1_5), Q5.7 (D1_1), Q5.8 (D1_2), Q5.9 (D1_3), Q5.10 (D1_4), Q5.14 (D1_5), Q6.7 (D1_1), Q6.8 (D1_2), Q6.9 (D1_3), Q6.10 (D1_4), Q6.14 (D1_5), Q7.7 (D1_1), Q7.8 (D1_2), Q7.9 (D1_3), Q7.10 (D1_4), Q7.14 (D1_5), Q8.7 (D1_1), Q8.8 (D1_2), Q8.9 (D1_3), Q8.10 (D1_4), Q8.14 (D1_5), Q9.7 (D1_1), Q9.8 (D1_2), Q9.9 (D1_3), Q9.10 (D1_4), Q9.14 (D1_5), Q10.7 (D1_1), Q10.8 (D1_2), Q10.9 (D1_3), Q10.10 (D1_4), Q10.14 (D1_5), Q11.7 (D1_1), Q11.8 (D1_2), Q11.9 (D1_3), Q11.10 (D1_4), Q11.14 (D1_5), Q12.7 (D1_1), Q12.8 (D1_2), Q12.9 (D1_3), Q12.10 (D1_4), Q12.14 (D1_5), R55.2, U18.5 (N.O)
/Motor0_CW: U3.61 (PB8), U24.2, U24.11
/Motor0_L: C44.1, J6.1, Q1.1 (S1), Q1.5 (D2_1), Q1.6 (D2_2), Q1.11 (D2_3), Q1.12 (D2_4), Q1.13 (D2_5)
/Motor0_L_PWM: U6.2 (IN), U24.13
/Motor0_PWM: U3.59 (PB7), U23.1, U24.3
/Motor0_R: C44.2, J6.2, Q2.1 (S1), Q2.5 (D2_1), Q2.6 (D2_2), Q2.11 (D2_3), Q2.12 (D2_4), Q2.13 (D2_5)
/Motor0_R_PWM: U7.2 (IN), U24.1
/Motor1_CW: U3.62 (PB9), U24.5, U24.8
/Motor1_L: C50.1, J10.1, Q7.1 (S1), Q7.5 (D2_1), Q7.6 (D2_2), Q7.11 (D2_3), Q7.12 (D2_4), Q7.13 (D2_5)
/Motor1_L_PWM: U12.2 (IN), U24.4
/Motor1_PWM: U3.58 (PB6), U23.3, U24.9
/Motor1_R: C50.2, J10.2, Q8.1 (S1), Q8.5 (D2_1), Q8.6 (D2_2), Q8.11 (D2_3), Q8.12 (D2_4), Q8.13 (D2_5)
/Motor1_R_PWM: U13.2 (IN), U24.10
/Motor2_CW: U3.40 (PC9), U25.2, U25.11
/Motor2_L: C45.1, J7.1, Q3.1 (S1), Q3.5 (D2_1), Q3.6 (D2_2), Q3.11 (D2_3), Q3.12 (D2_4), Q3.13 (D2_5)
/Motor2_L_PWM: U8.2 (IN), U25.13
/Motor2_PWM: U3.44 (PA11), U23.5, U25.3
/Motor2_R: C45.2, J7.2, Q4.1 (S1), Q4.5 (D2_1), Q4.6 (D2_2), Q4.11 (D2_3), Q4.12 (D2_4), Q4.13 (D2_5)
/Motor2_R_PWM: U9.2 (IN), U25.1
/Motor3_CW: U3.39 (PC8), U25.5, U25.8
/Motor3_L: C51.1, J11.1, Q9.1 (S1), Q9.5 (D2_1), Q9.6 (D2_2), Q9.11 (D2_3), Q9.12 (D2_4), Q9.13 (D2_5)
/Motor3_L_PWM: U14.2 (IN), U25.4
/Motor3_PWM: U3.43 (PA10), U23.9, U25.9
/Motor3_R: C51.2, J11.2, Q10.1 (S1), Q10.5 (D2_1), Q10.6 (D2_2), Q10.11 (D2_3), Q10.12 (D2_4), Q10.13 (D2_5)
/Motor3_R_PWM: U15.2 (IN), U25.10
/Motor4_CW: U3.38 (PC7), U26.2, U26.11
/Motor4_L: C46.1, J8.1, Q5.1 (S1), Q5.5 (D2_1), Q5.6 (D2_2), Q5.11 (D2_3), Q5.12 (D2_4), Q5.13 (D2_5)
/Motor4_L_PWM: U10.2 (IN), U26.13
/Motor4_PWM: U3.41 (PA8), U23.11, U26.3
/Motor4_R: C46.2, J8.2, Q6.1 (S1), Q6.5 (D2_1), Q6.6 (D2_2), Q6.11 (D2_3), Q6.12 (D2_4), Q6.13 (D2_5)
/Motor4_R_PWM: U11.2 (IN), U26.1
/Motor5_CW: U3.37 (PC6), U26.5, U26.8
/Motor5_L: C52.1, J12.1, Q11.1 (S1), Q11.5 (D2_1), Q11.6 (D2_2), Q11.11 (D2_3), Q11.12 (D2_4), Q11.13 (D2_5)
/Motor5_L_PWM: U16.2 (IN), U26.4
/Motor5_PWM: U3.42 (PA9), U23.13, U26.9
/Motor5_R: C52.2, J12.2, Q12.1 (S1), Q12.5 (D2_1), Q12.6 (D2_2), Q12.11 (D2_3), Q12.12 (D2_4), Q12.13 (D2_5)
/Motor5_R_PWM: U17.2 (IN), U26.10
/OSC_IN: C1.1, U3.5 (PH0), Y1.1
/OSC_OUT: C4.1, U3.6 (PH1), Y1.2
/SERVO_PWM: J9.3, U3.50 (PA15)
/SPI2_MISO: R64.2, U3.35 (PB14)
/SPI2_MOSI: R62.2, U3.36 (PB15)
/SPI2_NSS: R61.2, U3.33 (PB12)
/SPI2_SCK: R63.2, U3.34 (PB13)
/SW0: R2.2, SW2.2, U3.27 (PB1)
/SW1: R3.2, SW3.2, U3.28 (PB2)
/SWCLK: J1.3, U3.49 (PA14)
/SWDIO: J1.4, U3.46 (PA13)
/USART2_RX: J16.4, U3.17 (PA3)
/USART2_TX: J16.3, U3.16 (PA2)
/USART3_RX: U2.6 (UTx), U3.52 (PC11)
/USART3_TX: U2.5 (URx), U3.51 (PC10)
/~RST: C2.2, J1.5, SW1.1, U3.7 (NRST)
GND: C1.2, C2.1, C3.2, C4.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.1, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C43.2, C47.2, C48.2, C49.2, C53.1, C54.1, C57.1, C58.2, C59.2, C60.2, C61.2, D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), D26.1 (K), D30.2 (A), D31.1 (K), J1.1, J3.2, J3.4, J3.6, J3.8, J3.10, J3.12, J3.14, J3.16, J3.18, J3.20, J4.5 (GND), J5.1, J9.1, J13.1, J15.6 (VSS), J16.1, J18.1, JP2.1, Q1.3 (S2), Q2.3 (S2), Q3.3 (S2), Q4.3 (S2), Q5.3 (S2), Q6.3 (S2), Q7.3 (S2), Q8.3 (S2), Q9.3 (S2), Q10.3 (S2), Q11.3 (S2), Q12.3 (S2), Q14.3 (S), R1.2, R8.2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
unnamed: C5.1, R1.1, R4.1, U1.3 (FB)
unnamed: C6.1, D30.1 (K), L1.1, U1.6 (Lx)
unnamed: C6.2, U1.1 (BST)
unnamed: C7.1, U3.30 (VCAP_1)
unnamed: C25.1, D9.1 (K), U6.8 (VBOOT)
unnamed: C25.2, U6.6 (BRIDGE)
unnamed: C26.1, D10.1 (K), U7.8 (VBOOT)
unnamed: C26.2, U7.6 (BRIDGE)
unnamed: C27.1, D11.1 (K), U8.8 (VBOOT)
unnamed: C27.2, U8.6 (BRIDGE)
unnamed: C28.1, D12.1 (K), U9.8 (VBOOT)
unnamed: C28.2, U9.6 (BRIDGE)
unnamed: C29.1, D13.1 (K), U10.8 (VBOOT)
unnamed: C29.2, U10.6 (BRIDGE)
unnamed: C30.1, D14.1 (K), U11.8 (VBOOT)
unnamed: C30.2, U11.6 (BRIDGE)
unnamed: C37.1, D15.1 (K), U12.8 (VBOOT)
unnamed: C37.2, U12.6 (BRIDGE)
unnamed: C38.1, D16.1 (K), U13.8 (VBOOT)
unnamed: C38.2, U13.6 (BRIDGE)
unnamed: C39.1, D17.1 (K), U14.8 (VBOOT)
unnamed: C39.2, U14.6 (BRIDGE)
unnamed: C40.1, D18.1 (K), U15.8 (VBOOT)
unnamed: C40.2, U15.6 (BRIDGE)
unnamed: C41.1, D19.1 (K), U16.8 (VBOOT)
unnamed: C41.2, U16.6 (BRIDGE)
unnamed: C42.1, D20.1 (K), U17.8 (VBOOT)
unnamed: C42.2, U17.6 (BRIDGE)
unnamed: C55.1, U22.2 (VOUT)
unnamed: C56.1, U22.3 (CAP1N)
unnamed: C56.2, U22.4 (CAP1P)
unnamed: D1.2 (A), JP1.2
unnamed: D2.1 (K), U2.2 (GP0)
unnamed: D2.2 (A), R5.1
unnamed: D3.1 (K), U2.3 (GP1)
unnamed: D3.2 (A), R6.1
unnamed: D4.1 (K), U2.7 (GP2)
unnamed: D4.2 (A), R7.1
unnamed: D8.2 (A), J4.1 (VBUS)
unnamed: D22.2 (A), R53.1
unnamed: D23.2 (A), R54.1
unnamed: D24.2 (A), R55.1
unnamed: D25.2 (A), R56.1
unnamed: D26.2 (A), R57.1
unnamed: D27.1 (K), Q15.3 (D), U18.2
unnamed: D27.2 (A), JP2.2, Q14.2 (D), U18.1
unnamed: D28.2 (A), LS1.2, Q16.3 (C)
unnamed: D29.1 (K), J18.2
unnamed: D31.2 (A), R70.1
unnamed: J1.2, JP1.1
unnamed: J5.3, R13.2, R15.1
unnamed: J5.4, R12.2, R14.1
unnamed: J14.3, J14.4, U18.4
unnamed: J15.2 (DAT3/CD), R61.1
unnamed: J15.3 (CMD), R62.1
unnamed: J15.5 (CLK), R63.1
unnamed: J15.7 (DAT0), R64.1
unnamed: Q1.2 (G1), R22.1
unnamed: Q1.4 (G2), R23.1
unnamed: Q2.2 (G1), R24.1
unnamed: Q2.4 (G2), R25.1
unnamed: Q3.2 (G1), R26.1
unnamed: Q3.4 (G2), R27.1
unnamed: Q4.2 (G1), R28.1
unnamed: Q4.4 (G2), R29.1
unnamed: Q5.2 (G1), R30.1
unnamed: Q5.4 (G2), R31.1
unnamed: Q6.2 (G1), R32.1
unnamed: Q6.4 (G2), R33.1
unnamed: Q7.2 (G1), R40.1
unnamed: Q7.4 (G2), R41.1
unnamed: Q8.2 (G1), R42.1
unnamed: Q8.4 (G2), R43.1
unnamed: Q9.2 (G1), R44.1
unnamed: Q9.4 (G2), R45.1
unnamed: Q10.2 (G1), R46.1
unnamed: Q10.4 (G2), R47.1
unnamed: Q11.2 (G1), R48.1
unnamed: Q11.4 (G2), R49.1
unnamed: Q12.2 (G1), R50.1
unnamed: Q12.4 (G2), R51.1
unnamed: Q13.1 (G), R65.2, SW5.2 (B)
unnamed: Q15.1 (G), R52.2, SW4.2 (B)
unnamed: Q16.1 (B), R66.1
unnamed: Q16.2 (E), R67.2
unnamed: R8.1, U3.60 (BOOT0)
unnamed: R9.1, U2.4 (nRST)
unnamed: R10.1, U28.1 (blue_A)
unnamed: R11.1, U28.2 (green_A)
unnamed: R16.1, U6.3 (~SD)
unnamed: R17.1, U7.3 (~SD)
unnamed: R18.1, U8.3 (~SD)
unnamed: R19.1, U9.3 (~SD)
unnamed: R20.1, U10.3 (~SD)
unnamed: R21.1, U11.3 (~SD)
unnamed: R22.2, U6.7 (DRV_HO)
unnamed: R23.2, U6.5 (DRV_LO)
unnamed: R24.2, U7.7 (DRV_HO)
unnamed: R25.2, U7.5 (DRV_LO)
unnamed: R26.2, U8.7 (DRV_HO)
unnamed: R27.2, U8.5 (DRV_LO)
unnamed: R28.2, U9.7 (DRV_HO)
unnamed: R29.2, U9.5 (DRV_LO)
unnamed: R30.2, U10.7 (DRV_HO)
unnamed: R31.2, U10.5 (DRV_LO)
unnamed: R32.2, U11.7 (DRV_HO)
unnamed: R33.2, U11.5 (DRV_LO)
unnamed: R34.1, U12.3 (~SD)
unnamed: R35.1, U13.3 (~SD)
unnamed: R36.1, U14.3 (~SD)
unnamed: R37.1, U15.3 (~SD)
unnamed: R38.1, U16.3 (~SD)
unnamed: R39.1, U17.3 (~SD)
unnamed: R40.2, U12.7 (DRV_HO)
unnamed: R41.2, U12.5 (DRV_LO)
unnamed: R42.2, U13.7 (DRV_HO)
unnamed: R43.2, U13.5 (DRV_LO)
unnamed: R44.2, U14.7 (DRV_HO)
unnamed: R45.2, U14.5 (DRV_LO)
unnamed: R46.2, U15.7 (DRV_HO)
unnamed: R47.2, U15.5 (DRV_LO)
unnamed: R48.2, U16.7 (DRV_HO)
unnamed: R49.2, U16.5 (DRV_LO)
unnamed: R50.2, U17.7 (DRV_HO)
unnamed: R51.2, U17.5 (DRV_LO)
unnamed: R71.1, U28.3 (red_A)
unnamed: U23.2, U24.12
unnamed: U23.4, U24.6
unnamed: U23.6, U25.12
unnamed: U23.8, U25.6
unnamed: U23.10, U26.12
unnamed: U23.12, U26.6

Notes on the sheet:
EMG is HIGH -> EMG OFF
TIM1 CH1
TIM1 CH4
TIM3 CH1
TIM3 CH2
TIM4 CH2
TIM4 CH1
TIM2 CH1
TIM2 CH2
Brake is LOW -> Brake

Board: 2 copper layers, 100.0 x 100.0 mm, 236 parts (91 on the bottom side), 217 nets.

## KiCad design 2020/Robot_Lancer/新型ラインセンサ_3V3_out/LineSensor/rancer_sensor.kicad_pcb

Schematic: rancer_sensor.sch

Parts:
C1, C2: 0.1u; C_Rect_L07.0_W3.5_P05.0
D1, D5, D7: EBR33385; LED_D3.0mm
D2, D3: LED; LED_D3.0mm
D4, D6, D8: TLN119; LED_D3.0mm
P1: XH_08; JST_XH_B08B-XH-A_08x2.50mm_Straight
R1, R2, R3: 1k; myR
R4, R5, R7, R10, R12: 10k; myR
R6, R9: 100; myR
R8, R11: 1K; myR
R13, R15: 4.7k; 1608_WP
R14, R16: 10k; 1608_WP
RV1, RV2, RV3: 5k; myVR
U1, U4, U5: S7136
U2, U3: TPR-105F; QRE1113

Connections:
+5V: C1.1, C2.1, P1.2, R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, R9.1, R10.1, R11.1, R12.1, U1.2 (VCC), U4.2 (VCC), U5.2 (VCC)
/AN_1: P1.4, R13.2, R14.1
/AN_2: P1.7, R15.2, R16.1
/DB_CENTER: D5.1 (K), P1.5, R5.2, U4.3 (Vout)
/DB_L: D1.1 (K), P1.3, R4.2, U1.3 (Vout)
/DB_R: D7.1 (K), P1.6, R12.2, U5.3 (Vout)
GND: C1.2, C2.2, P1.1, R14.2, R16.2, U1.4 (GND), U2.2 (K), U2.4 (E), U3.2 (K), U3.4 (E), U4.4 (GND), U5.4 (GND)
unnamed: D1.2 (A), R1.2
unnamed: D2.1 (K), R7.2, R13.1, U2.3 (C)
unnamed: D2.2 (A), R8.2
unnamed: D3.1 (K), R10.2, R15.1, U3.3 (C)
unnamed: D3.2 (A), R11.2
unnamed: D4.1 (K), U1.1 (K)
unnamed: D5.2 (A), R2.2
unnamed: D6.1 (K), U4.1 (K)
unnamed: D7.2 (A), R3.2
unnamed: D8.1 (K), U5.1 (K)
unnamed: R6.2, U2.1 (A)
unnamed: R9.2, U3.1 (A)

Notes on the sheet:
DIGITAL_LEFT
DIGITAL_CENTER
DIGITAL_RIGHT
ANALOG_LEFT
ANALOG_RIGHT
