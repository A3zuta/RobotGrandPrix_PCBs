# Repository A3zuta/RobotGrandPrix_PCBs (continued)

## KiCad design 2020/Robot_Lancer/新型ラインセンサ_3V3_out/LineSensor/rancer_sensor.kicad_pcb (continued)

Board: 2 copper layers, 170.0 x 44.0 mm, 32 parts (5 on the bottom side), 19 nets.

## Commit log

2019-11-06 harahetta.
2019-11-06 test.
2019-11-06 no meaning
2019-11-06 ランサー以外の競技会にかかわる気はない.
2019-11-22 ランサー基板,こっちでバージョン管理した方がよさそう
2019-11-24 いい感じじゃね
2019-11-25 ブートストラップコンデンサ並べた,進捗git add -Agit add -A
2019-11-25 CAN通信の終端抵抗のジャンパー抵抗部分を忘れていた.追加,進捗git add -Agit add -A
2019-11-27 バックアップ
2019-12-01 Aloe
2019-12-01 いらないファイルとか消して整理した
2019-12-01 ランサー基板,配置のみ完
2019-12-02 不要ファイルを消去した
2019-12-02 2019/12/02進捗
2019-12-02 LED,FullColor,Valveのピンアサイン,もう少し考えた方がよさそうと考えた
2019-12-04 寸法線の追加
2019-12-09 2019/12/09
2019-12-12 back up
2019-12-12 2019/12/13_AM2:35
2019-12-13 2013/12/13 Aqua
2019-12-17 強引に完成させた
2019-12-17 圧縮した
2019-12-20 ランサー1機体目回路完成
2020-01-08 K-Kodani作ラインセンサ
2020-01-11 小谷ランサー基板
2020-01-15 仕様変わりスギィィィgit add -A
2020-01-15 つかれた
2020-01-17 ラインセンサ寸法線・和基板
2020-01-17 配置終わり
2020-01-19 pushできなかったからできるようにして,以前の内容をpush
2020-01-19 シルク表記改善
2020-01-21 信号線の配線終わり
2020-01-21 グランドビアまで打ち終えた.関税
2020-01-22 ああああああああああああああああああ
2020-01-23 ラインセンサmendoi
2020-01-23 基板のシルク表記にミスがあったので直した
2020-01-30 モータ電源用のリレーのN.O.とN.C.間違えた
2020-01-30 リレー逆転
2020-02-09 リレー,前のままであってた...
2020-02-23 抵抗値入れ忘れていたから入れた
2020-02-23 Pch FET,ミスっていた---git add -A!
2020-02-25 抵抗値入れた
2020-03-12 ポテンショメータ基板プロジェクトを追加した
2020-06-28 和ランサー基板に機体のロゴを追加した
2020-06-29 和ランサー3D CADほとんど完成
2022-03-09 KIT-RP版のAquarius_Sadalsuud基板の設計をし直した
2022-03-09 回路図・CADデータ・基板寸法図の更新
2022-03-09 fix:filepath
2022-04-26 Aqualius for KIT-RP Edition... complite
2022-04-27 for KIT-RP
2022-05-02 fix:motor-vdd 12V
2022-08-02 RC22 R2
