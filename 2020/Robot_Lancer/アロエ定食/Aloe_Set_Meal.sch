File: 2020/Robot_Lancer/アロエ定食/Aloe_Set_Meal.sch (KiCad schematic (older format))
At the start: 193 parts, among them J1 SWD, J10 MOTOR1, J11 MOTOR3, J12 MOTOR5, J13 BATT_IN, J14 3522-2, J2 ADC, J3 ADC_Vdd, J4 USB_B_Micro, J5 ENC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

Commit message: ランサー1機体目回路完成
Parts:
- added R? (x4): FILTER, symbol Device:R
Connections:
- net +3V3: now also J?.4 (VDD)
- net GND: now also J?.6 (VSS)
- net at J?.2 (DAT3/CD): now also R?.1
- net at J?.3 (CMD): now also R?.1
- net at J?.5 (CLK): now also R?.1
- net at J?.7 (DAT0): now also R?.1
- new net SPI_MISO: R?.2
- new net SPI_MOSI: R?.2
- new net SPI_NSS: R?.2
- new net SPI_SCK: R?.2
- no-connect marks 8 -> 12
Other:
- moved on the sheet: J?, U4
Changed lines of the file:
@@
 L Miz:SW_ROTARY_16 U4
 U 1 1 5DED35D7
-P 4625 9375
-F 0 "U4" H 4625 9812 60  0000 C CNN
-F 1 "ROTARY" H 4625 9706 60  0000 C CNN
-F 2 "Mizz_lib:rotary_0F" H 4625 9375 60  0001 C CNN
-F 3 "" H 4625 9375 60  0001 C CNN
-	1    4625 9375
+P 4675 9250
+F 0 "U4" H 4675 9687 60  0000 C CNN
+F 1 "ROTARY" H 4675 9581 60  0000 C CNN
+F 2 "Mizz_lib:rotary_0F" H 4675 9250 60  0001 C CNN
+F 3 "" H 4675 9250 60  0001 C CNN
+	1    4675 9250
 	1    0    0    -1
 $EndComp
@@
 L power:GND #PWR0169
 U 1 1 5DED539B
-P 5075 9375
-F 0 "#PWR0169" H 5075 9125 50  0001 C CNN
-F 1 "GND" H 5080 9202 50  0000 C CNN
-F 2 "" H 5075 9375 50  0001 C CNN
-F 3 "" H 5075 9375 50  0001 C CNN
-	1    5075 9375
+P 5125 9250
+F 0 "#PWR0169" H 5125 9000 50  0001 C CNN
+F 1 "GND" H 5130 9077 50  0000 C CNN
+F 2 "" H 5125 9250 50  0001 C CNN
+F 3 "" H 5125 9250 50  0001 C CNN
+	1    5125 9250
 	1    0    0    -1
 $EndComp
@@
 L power:GND #PWR0170
 U 1 1 5DED56A6
-P 4175 9375
-F 0 "#PWR0170" H 4175 9125 50  0001 C CNN
-F 1 "GND" H 4180 9202 50  0000 C CNN
-F 2 "" H 4175 9375 50  0001 C CNN
-F 3 "" H 4175 9375 50  0001 C CNN
-	1    4175 9375
-	1    0    0    -1
-$EndComp
-Text Label 4175 9525 2    50   ~ 0
+P 4225 9250
+F 0 "#PWR0170" H 4225 9000 50  0001 C CNN
+F 1 "GND" H 4230 9077 50  0000 C CNN
+F 2 "" H 4225 9250 50  0001 C CNN
+F 3 "" H 4225 9250 50  0001 C CNN
+	1    4225 9250
+	1    0    0    -1
+$EndComp
+Text Label 4225 9400 2    50   ~ 0
 ADRESS0
-Text Label 4175 9225 2    50   ~ 0
+Text Label 4225 9100 2    50   ~ 0
 ADRESS1
-Text Label 5075 9525 0    50   ~ 0
+Text Label 5125 9400 0    50   ~ 0
 ADRESS2
-Text Label 5075 9225 0    50   ~ 0
+Text Label 5125 9100 0    50   ~ 0
 ADRESS3
 Text Label 1375 10075 2    50   ~ 0
@@
 L Connector:Micro_SD_Card_Det_Hirose_DM3AT J?
 U 1 1 5E090CDD
-P 3975 10525
-F 0 "J?" H 3925 11342 50  0000 C CNN
-F 1 "microSD" H 3925 11251 50  0000 C CNN
-F 2 "" H 6025 11225 50  0001 C CNN
-F 3 "https://www.hirose.com/product/en/download_file/key_name/DM3/category/Catalog/doc_file_id/49662/?file_category_id=4&item_id=195&is_series=1" H 3975 10625 50  0001 C CNN
-	1    3975 10525
-	1    0    0    -1
-$EndComp
+P 3975 10450
+F 0 "J?" H 3925 11267 50  0000 C CNN
+F 1 "microSD" H 3925 11176 50  0000 C CNN
+F 2 "" H 6025 11150 50  0001 C CNN
+F 3 "https://www.hirose.com/product/en/download_file/key_name/DM3/category/Catalog/doc_file_id/49662/?file_category_id=4&item_id=195&is_series=1" H 3975 10550 50  0001 C CNN
+	1    3975 10450
+	1    0    0    -1
+$EndComp
+$Comp
+L Device:R R?
+U 1 1 5DFD062A
+P 2925 10150
+F 0 "R?" V 2718 10150 50  0000 C CNN
+F 1 "FILTER" V 2809 10150 50  0000 C CNN
+F 2 "" V 2855 10150 50  0001 C CNN
+F 3 "~" H 2925 10150 50  0001 C CNN
+	1    2925 10150
+	0    1    1    0
+$EndComp
+$Comp
+L Device:R R?
+U 1 1 5DFD12BB
+P 2925 10250
+F 0 "R?" V 2718 10250 50  0000 C CNN
+F 1 "FILTER" V 2809 10250 50  0000 C CNN
+F 2 "" V 2855 10250 50  0001 C CNN
+F 3 "~" H 2925 10250 50  0001 C CNN
+	1    2925 10250
+	0    1    1    0
+$EndComp
+$Comp
+L Device:R R?
+U 1 1 5DFD13CA
+P 2925 10450
+F 0 "R?" V 2718 10450 50  0000 C CNN
+F 1 "FILTER" V 2809 10450 50  0000 C CNN
+F 2 "" V 2855 10450 50  0001 C CNN
+F 3 "~" H 2925 10450 50  0001 C CNN
+	1    2925 10450
+	0    1    1    0
+$EndComp
+$Comp
+L Device:R R?
+U 1 1 5DFD1561
+P 2925 10650
+F 0 "R?" V 2718 10650 50  0000 C CNN
+F 1 "FILTER" V 2809 10650 50  0000 C CNN
+F 2 "" V 2855 10650 50  0001 C CNN
+F 3 "~" H 2925 10650 50  0001 C CNN
+	1    2925 10650
+	0    1    1    0
+$EndComp
+NoConn ~ 3075 10050
+$Comp
+L power:+3.3V #PWR?
+U 1 1 5E00146C
+P 3075 10350
+F 0 "#PWR?" H 3075 10200 50  0001 C CNN
+F 1 "+3.3V" H 3090 10523 50  0000 C CNN
+F 2 "" H 3075 10350 50  0001 C CNN
+F 3 "" H 3075 10350 50  0001 C CNN
+	1    3075 10350
+	1    0    0    -1
+$EndComp
+$Comp
+L power:GND #PWR?
+U 1 1 5E001E68
+P 3075 10550
+F 0 "#PWR?" H 3075 10300 50  0001 C CNN
+F 1 "GND" H 3080 10377 50  0000 C CNN
+F 2 "" H 3075 10550 50  0001 C CNN
+F 3 "" H 3075 10550 50  0001 C CNN
+	1    3075 10550
+	1    0    0    -1
+$EndComp
+NoConn ~ 3075 10750
+Text Label 2775 10150 2    50   ~ 0
+SPI_NSS
+Text Label 2775 10250 2    50   ~ 0
+SPI_MOSI
+Text Label 2775 10450 2    50   ~ 0
+SPI_SCK
+Text Label 2775 10650 2    50   ~ 0
+SPI_MISO
+NoConn ~ 3075 10850
+NoConn ~ 3075 10950
+Text Label 1075 5375 2    50   ~ 0
+SPI_NSS
+Text Label 1075 5475 2    50   ~ 0
+SPI_MOSI
+Text Label 1075 5675 2    50   ~ 0
+SPI_SCK
+Text Label 1075 5875 2    50   ~ 0
+SPI_MISO
 $EndSCHEMATC

Commit message: 小谷ランサー基板
Parts:
- removed J9: BATT_IN, Mizz_lib:XT60_F, symbol Connector_Generic:Conn_01x02
- added C53, C54: 0.1u, Capacitor_SMD:C_0603_1608Metric, symbol Device:C
- added C55, C56: 1u, Capacitor_SMD:C_0603_1608Metric, symbol Device:C
- added D28: DIODE, Diode_SMD:D_SOD-123, symbol Miz:DIODE_rev
- added J16: SERIAL1, Mizz_lib:XA_4P, symbol Connector_Generic:Conn_01x04
- added LS1: Speaker, Mizz_lib:UGCT7525AN4, symbol Device:Speaker
- added Q15: FET_P, Package_TO_SOT_SMD:SOT-23W, symbol Device:Q_NMOS_GSD
- added Q16: NPN, Package_TO_SOT_SMD:SOT-23W, symbol Device:Q_NPN_BEC
- added R59, R60, R65, R68, R69, R71: 10k, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- added R66: 10, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- added R67: 120, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- added R70: 100k, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- added SW5: MAIN_SW, Mizz_lib:2MS1-T1-B4-VS2-Q-E, symbol Switch:SW_DPDT_x2
- added U20: LOGO, Mizz_lib:Sagittarius_Alnasl_silk_40.0x11.4, symbol Miz:LOGO
- added U21: LOGO, Mizz_lib:Goukazal_25.0x18.8_S.Itoh_silk, symbol Miz:LOGO
- added U22: AQM0802, Mizz_lib:AQM0802, symbol Miz:AQM1602
- C11, C13, C25, C26, C27, C28, C29, C30, C37, C38, C39, C40, C41, C42, C48, C49, C8: footprint (none) -> Capacitor_SMD:C_0805_2012Metric
- C43, C47: footprint (none) -> Mizz_lib:CAPAE1300X1400N
- C9: footprint (none) -> Capacitor_SMD:C_0603_1608Metric
- D1, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D27, D7, D8, D9: footprint (none) -> Diode_SMD:D_SOD-123
- J1: footprint (none) -> Connector_PinHeader_2.54mm:PinHeader_1x06_P2.54mm_Vertical
- J13: footprint Mizz_lib:XT60_F -> Mizz_lib:XT60_M
- J15: renamed from J?; footprint (none) -> Connector_Card:microSD_HC_Hirose_DM3AT-SF-PEJM5
- J2: footprint (none) -> Connector_PinHeader_2.54mm:PinHeader_1x10_P2.54mm_Vertical
- J3: footprint (none) -> Connector_PinHeader_2.54mm:PinHeader_2x10_P2.54mm_Vertical
- J4: value USB_B_Micro -> SERIAL0; footprint (none) -> Connector_USB:USB_Micro-B_Molex_47346-0001
- J5: footprint (none) -> Mizz_lib:XA_4P
- JP1: value Jumper -> SWD_3.3V_JP; footprint (none) -> Mizz_lib:GS2
- JP2: footprint (none) -> Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical
- R12, R13: value 10k -> 1k
- R14, R15: value 100 -> 4.7k
- R61, R62, R63, R64: renamed from R?; footprint (none) -> Resistor_SMD:R_0603_1608Metric
Connections:
- net SERIALx_RX is gone; now on net USART3_RX: U2.6 (UTx)
- net SERIALx_TX is gone; now on net USART3_TX: U2.5 (URx)
- net SPI_MISO is gone; now on net SPI2_MISO: R64.2
- net SPI_MOSI is gone; now on net SPI2_MOSI: R62.2
- net SPI_NSS is gone; now on net SPI2_NSS: R61.2
- net SPI_SCK is gone; now on net SPI2_SCK: R63.2
- net +3V3: now also C54.2, C55.2, D28.1 (K), LS1.1, R68.1, R69.1, U22.5 (VDD), U22.9 (/RST); no longer R12.1, R13.1
- net +5V: now also R12.1, R13.1, C53.2, J16.2 (Pin_2), Q15.2 (S); no longer C11.1, D7.1 (K)
- net +BATT: now also J14.1, R70.1; no longer J14.4
- net ADC4: now also U3.14 (PA0)
- net ADC5: now also U3.15 (PA1)
- net ADC6: now also U3.20 (PA4)
- net ADC7: now also U3.21 (PA5)
- net ADC8: now also U3.24 (PC4)
- net ADC9: now also U3.25 (PC5)
- net ADRESS0: now also U3.54 (PD2)
- net ADRESS1: now also U3.55 (PB3)
- net ADRESS2: now also U3.56 (PB4)
- net ADRESS3: now also U3.57 (PB5)
- net EMG_IO: now also U3.4 (PC15)
- net ENC_CH1: now also U3.22 (PA6), R59.1
- net ENC_CH2: now also U3.23 (PA7), R60.1
- net FB: now also C11.1
- net GND: now also C53.1, C54.1, J16.1 (Pin_1), R59.2, R60.2, R67.1, R71.2, SW5.3 (C), U22.6 (VSS)
- net LED0: now also U3.2 (PC13)
- net LED1: now also U3.3 (PC14)
- net Motor0_L_PWM: now also U3.37 (PC6)
- net Motor0_R_PWM: now also U3.38 (PC7)
- net Motor1_L_PWM: now also U3.39 (PC8)
- net Motor1_R_PWM: now also U3.40 (PC9)
- net Motor2_L_PWM: now also U3.41 (PA8)
- net Motor2_R_PWM: now also U3.42 (PA9)
- net Motor3_L_PWM: now also U3.43 (PA10)
- net Motor3_R_PWM: now also U3.44 (PA11)
- net Motor4_L_PWM: now also U3.61 (PB8)
- net Motor4_R_PWM: now also U3.62 (PB9)
- net Motor5_L_PWM: now also U3.58 (PB6)
- net Motor5_R_PWM: now also U3.59 (PB7)
- net SW0: now also U3.27 (PB1)
- net SW1: now also U3.28 (PB2)
- net SWCLK: now also U3.49 (PA14)
- net SWDIO: now also U3.46 (PA13)
- net USART2_TX: now reaches U3.16 (PA2)
- net USART2_TX: now also J16.3 (Pin_3)
- net USART2_RX: now reaches U3.17 (PA3)
- net USART2_RX: now also J16.4 (Pin_4)
- net Batter_Voltage_Read: now reaches U3.26 (PB0)
- net Batter_Voltage_Read: now also R70.2, R71.1
- net I2C2_SCL: now reaches U3.29 (PB10)
- net I2C2_SCL: now also R68.2, U22.8 (SCL)
- net SPI2_NSS: now reaches U3.33 (PB12)
- net SPI2_SCK: now reaches U3.34 (PB13)
- net SPI2_MISO: now reaches U3.35 (PB14)
- net SPI2_MOSI: now reaches U3.36 (PB15)
- net Buzzer_PWM: now reaches U3.50 (PA15)
- net Buzzer_PWM: now also R66.2
- net USART3_TX: now reaches U3.51 (PC10)
- net USART3_RX: now reaches U3.52 (PC11)
- net I2C2_SDA: now reaches U3.53 (PC12)
- net I2C2_SDA: now also R69.2, U22.7 (SDA)
- net at J14.3, U18.4: now also J14.4; no longer J14.1
- new net: Q15.1 (G), R65.2, SW5.2 (B)
- new net: D28.2 (A), LS1.2, Q16.3 (C)
- new net: Q16.1 (B), R66.1
- new net: Q16.2 (E), R67.2
- new net: C55.1, U22.2 (VOUT)
- new net: C56.1, U22.3 (CAP1N)
- new net: C56.2, U22.4 (CAP1P)
- new net 5Vc: D7.1 (K), Q15.3 (D), R65.1
- no-connect marks 12 -> 15
Other:
- note added: "TIM1 CH1"
- note added: "TIM1 CH4"
- note added: "TIM2 CH1"
- note added: "TIM3 CH1"
- note added: "TIM3 CH2"
- note added: "TIM4 CH1"
- note added: "TIM4 CH4"
- note added: "TIM8 CH1"
- note added: "TIM8 CH4"
- moved on the sheet: C11, C13, C15, C18, C3, C5, C6, C8, D2, D21, D3, D4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

Commit message: 仕様変わりスギィィィgit add -A
Parts:
- removed R70: 100k, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- removed R71: 10k, Resistor_SMD:R_0603_1608Metric, symbol Device:R
- added C57, C58, C59, C60, C61: 0.1u, Capacitor_SMD:C_0603_1608Metric, symbol Device:C
- added D29: DIODE, Diode_SMD:D_SOD-123, symbol Miz:DIODE_rev
- added J17: VOLTMETER, Mizz_lib:V_BattMeter, symbol Connector_Generic:Conn_01x02
- added J18: TO_VOLTMETER, Mizz_lib:XA_2LC, symbol Connector_Generic:Conn_01x02
- added J9: SERVO, Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Vertical, symbol Connector_Generic:Conn_01x03
- added U23: 74HCT04, Package_SO:SOIC-14_3.9x8.7mm_P1.27mm, symbol 74xx:74HCT04
- added U24, U25, U26: 74HC02, Package_SO:SOIC-14_3.9x8.7mm_P1.27mm, symbol 74xx:74HC02
- U18: value V23086-C1001-A403 -> V23086-C1001
- U21: footprint Mizz_lib:Goukazal_25.0x18.8_S.Itoh_silk -> Mizz_lib:Goukazal_10.0x7.5_S.Itoh_silk
Connections:
- net Batter_Voltage_Read is gone; now on net ADC7: U3.26 (PB0)
- net +3V3: now also C58.1, C59.1, C60.1, C61.1, U23.14 (VCC), U24.14 (VCC), U25.14 (VCC), U26.14 (VCC)
- net +BATT: now also D29.2 (A)
- net ADC5: now also U3.20 (PA4); no longer U3.15 (PA1)
- net ADC6: now also U3.21 (PA5); no longer U3.20 (PA4)
- net ADC7: no longer U3.21 (PA5)
- net Buzzer_PWM: now also U3.15 (PA1); no longer U3.50 (PA15)
- net GND: now also C57.1, C58.2, C59.2, C60.2, C61.2, J18.1 (Pin_1), J9.1 (Pin_1), U23.7 (GND), U24.7 (GND), U25.7 (GND), U26.7 (GND)
- net MOTOR_BATT: now also C57.2, J9.2 (Pin_2)
- net Motor0_L_PWM: now also U24.13; no longer U3.37 (PC6)
- net Motor0_R_PWM: now also U24.1; no longer U3.38 (PC7)
- net Motor1_L_PWM: now also U24.4; no longer U3.39 (PC8)
- net Motor1_R_PWM: now also U24.10; no longer U3.40 (PC9)
- net Motor2_L_PWM: now also U25.13; no longer U3.41 (PA8)
- net Motor2_R_PWM: now also U25.1; no longer U3.42 (PA9)
- net Motor3_L_PWM: now also U25.4; no longer U3.43 (PA10)
- net Motor3_R_PWM: now also U25.10; no longer U3.44 (PA11)
- net Motor4_L_PWM: now also U26.13; no longer U3.61 (PB8)
- net Motor4_R_PWM: now also U26.1; no longer U3.62 (PB9)
- net Motor5_L_PWM: now also U26.4; no longer U3.58 (PB6)
- net Motor5_R_PWM: now also U26.10; no longer U3.59 (PB7)
- new net: U23.4, U24.6
- new net: U23.2, U24.12
- new net: D29.1 (K), J18.2 (Pin_2)
- new net: U23.8, U25.6
- new net: U23.6, U25.12
- new net: U23.12, U26.6
- new net: U23.10, U26.12
- new net Motor0_CW: U24.11, U24.2, U3.37 (PC6)
- new net Motor0_PWM: U23.1, U24.3, U3.41 (PA8)
- new net Motor1_CW: U24.5, U24.8, U3.38 (PC7)
- new net Motor1_PWM: U23.3, U24.9, U3.42 (PA9)
- new net Motor2_CW: U25.11, U25.2, U3.39 (PC8)
- new net Motor2_PWM: U23.5, U25.3, U3.43 (PA10)
- new net Motor3_CW: U25.5, U25.8, U3.40 (PC9)
- new net Motor3_PWM: U23.9, U25.9, U3.44 (PA11)
- new net Motor4_CW: U26.11, U26.2, U3.61 (PB8)
- new net Motor4_PWM: U23.11, U26.3, U3.58 (PB6)
- new net Motor5_CW: U26.5, U26.8, U3.62 (PB9)
- new net Motor5_PWM: U23.13, U26.9, U3.59 (PB7)
- new net SERVO_PWM: J9.3 (Pin_3), U3.50 (PA15)
- no-connect marks 15 -> 17
Other:
- note added: "Brake is LOW -> Brake"
- note added: "TIM2 CH2\n"
- note added: "TIM4 CH2"
- note removed: "TIM4 CH4"
- note removed: "TIM8 CH1"
- note removed: "TIM8 CH4"
- moved on the sheet: C15, C19, C20, C21, C22, C23, C24, C25, C26, C27, C28, C29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
